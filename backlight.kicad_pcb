# Repository realthunder/hmo_pcb_backlight

## KiCad design backlight.kicad_pcb

Parts:
C1: 10uF; TantalC_SizeR_EIA-2012
P1: CONN_01X05; Molex_Panelmate-53780-0470_04x1.25mm_Angled
U1, U2, U3, U4, U5, U6, U7, U8, U9: APA102C

Connections:
/CLK: P1.3, U1.2 (CI)
/MOSI: P1.4, U1.1 (DI)
GND: C1.2, P1.1, U1.3 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND), U8.3 (GND), U9.3 (GND)
unnamed: U1.5 (CO), U2.2 (CI)
unnamed: U1.6 (DO), U2.1 (DI)
unnamed: U2.5 (CO), U3.2 (CI)
unnamed: U2.6 (DO), U3.1 (DI)
unnamed: U3.5 (CO), U4.2 (CI)
unnamed: U3.6 (DO), U4.1 (DI)
unnamed: U4.5 (CO), U5.2 (CI)
unnamed: U4.6 (DO), U5.1 (DI)
unnamed: U5.5 (CO), U6.2 (CI)
unnamed: U5.6 (DO), U6.1 (DI)
unnamed: U6.5 (CO), U7.2 (CI)
unnamed: U6.6 (DO), U7.1 (DI)
unnamed: U7.5 (CO), U8.2 (CI)
unnamed: U7.6 (DO), U8.1 (DI)
unnamed: U8.5 (CO), U9.2 (CI)
unnamed: U8.6 (DO), U9.1 (DI)
VCC: C1.1, P1.2, U1.4 (VCC), U2.4 (VCC), U3.4 (VCC), U4.4 (VCC), U5.4 (VCC), U6.4 (VCC), U7.4 (VCC), U8.4 (VCC), U9.4 (VCC)

Board: 2 copper layers, 27.8 x 19.6 mm, 11 parts (0 on the bottom side), 20 nets.

## Commit log

2016-06-08 Init commit
2016-06-09 Modified pcb design
2016-06-09 Added FlatCAM project file
2016-06-09 Avoid long staight trace
    To make it more auto level friendly
2016-06-09 Updated flatcam project
2016-06-23 Modified pcb design for easy solidering
2016-07-12 Fixed connection error
2016-10-26 Added missing lib cache
